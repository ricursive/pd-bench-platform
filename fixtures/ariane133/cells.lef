VERSION 5.8 ;
UNITS
  DATABASE MICRONS 4000 ;
END UNITS

MACRO sram_asap7_16x256_1rw
  CLASS BLOCK ;
  SIZE 24.0000 BY 33.0000 ;
END sram_asap7_16x256_1rw

MACRO INVx1_ASAP7_75t_R
  CLASS CORE ;
  SIZE 0.2700 BY 1.0800 ;
END INVx1_ASAP7_75t_R

MACRO BUFx2_ASAP7_75t_R
  CLASS CORE ;
  SIZE 0.3780 BY 1.0800 ;
END BUFx2_ASAP7_75t_R

MACRO NAND2x1_ASAP7_75t_R
  CLASS CORE ;
  SIZE 0.3240 BY 1.0800 ;
END NAND2x1_ASAP7_75t_R

MACRO NOR2x1_ASAP7_75t_R
  CLASS CORE ;
  SIZE 0.3240 BY 1.0800 ;
END NOR2x1_ASAP7_75t_R

MACRO AOI22x1_ASAP7_75t_R
  CLASS CORE ;
  SIZE 0.4860 BY 1.0800 ;
END AOI22x1_ASAP7_75t_R

MACRO DFFHQNx1_ASAP7_75t_R
  CLASS CORE ;
  SIZE 0.8640 BY 1.0800 ;
END DFFHQNx1_ASAP7_75t_R

